File: pcb/cad/qds-cv.kicad_pcb (KiCad board)
At the start: 2 copper layers, 219 x 159 mm, 156 parts, among them J101 DB25 Female, J102 Conn_01x08, J201 Conn_Coaxial, J301 Conn_Coaxial, J401 Conn_Coaxial, J501 Conn_Coaxial, J701 Conn_Coaxial, J702 DB9_Female, J901 Barrel_Jack_Switch, K701 FINDER-30.22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

Commit message: Finish PCB layout including revision close #9 close #10 close #11 close #12 close #13 close #14 close #15 close #16
Parts:
- TP120, TP121: renamed from ?; value (none) -> TestPoint; footprint (none) -> qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose
- moved TP119 14.2 mm to (211.6, 126.5)
- moved TP109 6.60 mm to (198.4, 126.5)
- moved TP101 4.50 mm to (123.7, 90.9)
- moved TP108 3.56 mm to (190.2, 126.5)
- moved TP116 3.56 mm to (173.0, 126.5)
- moved TP107 3.30 mm to (178.3, 126.5)
- moved TP110 2.79 mm to (206.0, 126.5)
- moved J201 2.19 mm to (306.1, 109.5)
- moved J901 1.81 mm to (307.1, 185.8)
- moved J301 1.46 mm to (306.1, 91.2)
- moved TP104 1.27 mm to (235.5, 114.3)
- moved SW701 0.98 mm to (315.2, 168.7)
- moved SW702 0.76 mm to (315.2, 158.5)
- moved J401 0.73 mm to (306.0, 72.9)
- moved TP105 0.63 mm to (229.7, 114.3)
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Connections:
- J102 pad 2: -14V -> Earth
- J102 pad 3: +14V -> -14V
- J102 pad 4: Earth -> +14V
- R707 pad 1: +14V -> +15V
Routing:
- net +14V: track 184.8 -> 125.9 mm, vias 5 -> 4
- net +15V: track 55.9 -> 101.6 mm, vias 0 -> 1
- net +5V: track 515.1 -> 520.4 mm
- net -14V: track 64.8 -> 69.3 mm
- net GND-ISO-A: track 12.0 -> 16.4 mm
- net /VT2: track 21.5 -> 25.2 mm
- net /Quench trigger/REMOTE_RST+: track 254.6 -> 252.6 mm
- net Net-(J701-Pad1): track 137.8 -> 139.3 mm
- net Net-(C202-Pad2): track 26.4 -> 27.7 mm
- net /Quench trigger/SW_TRIG+: track 125.3 -> 126.5 mm
- net Net-(Q701-Pad1): track 103.6 -> 104.6 mm
- net Earth: track 3.67 -> 2.87 mm, vias 9 -> 24
- net Net-(J201-Pad1): track 134.1 -> 134.7 mm
- net /Quench trigger/SW_TRIG-: track 266.6 -> 267.1 mm
- net /Detection validation/TRIG-CH-B: track 38.2 -> 37.7 mm

Commit message: Plot gerber files, export schematic in PDF
Routing:
- net GND-ISO-A: track 16.4 -> 19.5 mm

Commit message: Assign test point values, arrange PCB fabrication layers
Parts:
- TP103: value TestPoint -> TRIG-CH-A
- TP104: value TestPoint -> TRIG-CH-B
- TP105: value TestPoint -> TRIG-CH-C
- TP106: value TestPoint -> TRIC-CH-D
- TP107: value TestPoint -> +15V
- TP108: value TestPoint -> -14V
- TP109: value TestPoint -> +14V
- TP110: value TestPoint -> +5V
- TP111: value TestPoint -> +5V-ISO-A
- TP112, TP113: value TestPoint -> GND-ISO-A
- TP116, TP117, TP118, TP119, TP120, TP121: value TestPoint -> GND
- TP203: value TestPoint -> V-VAL
- TP204: value TestPoint -> Vdiff1+
- TP205: value TestPoint -> Vdiff1-
- TP206: value TestPoint -> Vdiff2+
- TP207: value TestPoint -> Vdiff2-
- TP208: value TestPoint -> Vsing
- TP701: value TestPoint -> FF-CLK
- TP702: value TestPoint -> Q-TRIG
Connections:
- J101 pad 12: /VT1 -> /VT2
- J101 pad 21: /VT2 -> /VT1
- J101 pad 24: /VT1 -> /VT2
- J101 pad 9: /VT2 -> /VT1
- R204 pad 1: /VT2 -> /VT1
- R210 pad 1: /VT1 -> /VT2
- TP101 pad 1: /VT2 -> /VT1
- TP102 pad 1: /VT1 -> /VT2
Routing:
- net /VT2: track 25.2 -> 25.8 mm
- net /VT1: track 25.8 -> 25.2 mm

Commit message: Rectify 74574 partnumber, generate HTML BOM list
Parts:
- TP106: value TRIC-CH-D -> TRIG-CH-D
Changed lines of the file:
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@@
     (tags "S0-20 ")
     (property "Description" " Octal Edge-Triggered D-Flip-Flips With 3-State Outputs")
-    (property "Manufacturer" "Texas")
-    (property "Part Number" "SN74HCT574")
+    (property "Manufacturer" "NXP")
+    (property "Part Number" "74HC574D")
     (property "Sheetfile" "quench-trigger.kicad_sch")
     (property "Sheetname" "Quench trigger")
@@
       (effects (font (size 1 1) (thickness 0.15)))
     )
-    (fp_text value "TRIC-CH-D" (at 0 3.8 225) (layer "F.Fab")
-      (effects (font (size 1 1) (thickness 0.15)))
-    )
+    (fp_text value "TRIG-CH-D" (at 0 3.8 225) (layer "F.Fab")
+      (effects (font (size 1 1) (thickness 0.15)))
+    )

Commit message: Increase value of resistor in series with relay coil (R707)
Parts:
- C208: footprint Capacitor_SMD:C_1206_3216Metric -> qds-cv-lib:C_1206_3216Metric_Small_Pad
- R707: value 120 -> 180
Changed lines of the file:
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@@
     (descr "Resistor SMD 0805 (2012 Metric), square (rectangular) end terminal, IPC_7351 nominal with elongated pad for handsoldering. (Body size source: IPC-SM-782 page 72, https://www.pcb-3d.com/wordpress/wp-content/uploads/ipc-sm-782a_amendment_1_and_2.pdf), generated with kicad-footprint-generator")
     (tags "resistor handsolder")
-    (property "CNPEM Code" "MT100270")
-    (property "Description" "Resistor 120R 1% 0.125W SMD 0805")
-    (property "Manufacturer" "Panasonic Electronic Components")
-    (property "Part Number" "ERJ-6ENF1200V")
+    (property "Description" "Resistor 180R 1% 0.125W SMD 0805")
+    (property "Manufacturer" "RoyalOhm")
+    (property "Part Number" "0805W8F1800T5E")
     (property "Sheetfile" "quench-trigger.kicad_sch")
     (property "Sheetname" "Quench trigger")
-    (property "Vendor Link" "https://www.digikey.com/en/products/detail/panasonic-electronic-components/ERJ-6ENF1200V/1746457?utm_adgroup=Resistors&utm_source=google&utm_medium=cpc&utm_campaign=Dynamic%20Search_PT_Product&utm_term=&utm_content=Resistors&gclid=Cj0KCQjwiZqhBhCJARIsACHHEH-pu6fwXPqBkHKqSkQnzptc673XOtJCxcLr698HcilOwq3CV2g-xmQaAoZhEALw_wcB")
     (attr smd)
     (fp_text reference "R707" (at 0 -1.65) (layer "F.SilkS")
       (effects (font (size 1 1) (thickness 0.15)))
     )
-    (fp_text value "120" (at 0 1.65) (layer "F.Fab")
+    (fp_text value "180" (at 0 1.65) (layer "F.Fab")
       (effects (font (size 1 1) (thickness 0.15)))
     )
@@
     )
   )
-  (footprint "Capacitor_SMD:C_1206_3216Metric" (layer "F.Cu")
+  (footprint "qds-cv-lib:C_1206_3216Metric_Small_Pad" (layer "F.Cu")
     (at 144.4746 100.33 -90)
     (descr "Capacitor SMD 1206 (3216 Metric), square (rectangular) end terminal, IPC_7351 nominal, (Body size source: IPC-SM-782 page 76, https://www.pcb-3d.com/wordpress/wp-content/uploads/ipc-sm-782a_amendment_1_and_2.pdf), generated with kicad-footprint-generator")
@@
       (effects (font (size 0.8 0.8) (thickness 0.12)))
     )
+    (fp_line (start -0.711252 0.91) (end 0.711252 0.91) (layer "F.SilkS") (width 0.12))
     (fp_line (start -0.711252 -0.91) (end 0.711252 -0.91) (layer "F.SilkS") (width 0.12))
-    (fp_line (start -0.711252 0.91) (end 0.711252 0.91) (layer "F.SilkS") (width 0.12))
-    (fp_line (start -2.3 1.15) (end -2.3 -1.15) (layer "F.CrtYd") (width 0.05))
+    (fp_line (start 2.3 1.15) (end -2.3 1.15) (layer "F.CrtYd") (width 0.05))
     (fp_line (start -2.3 -1.15) (end 2.3 -1.15) (layer "F.CrtYd") (width 0.05))
     (fp_line (start 2.3 -1.15) (end 2.3 1.15) (layer "F.CrtYd") (width 0.05))
-    (fp_line (start 2.3 1.15) (end -2.3 1.15) (layer "F.CrtYd") (width 0.05))
-    (fp_line (start -1.6 0.8) (end -1.6 -0.8) (layer "F.Fab") (width 0.1))
+    (fp_line (start -2.3 1.15) (end -2.3 -1.15) (layer "F.CrtYd") (width 0.05))
     (fp_line (start 1.6 0.8) (end -1.6 0.8) (layer "F.Fab") (width 0.1))
     (fp_line (start -1.6 -0.8) (end 1.6 -0.8) (layer "F.Fab") (width 0.1))
+    (fp_line (start -1.6 0.8) (end -1.6 -0.8) (layer "F.Fab") (width 0.1))
     (fp_line (start 1.6 -0.8) (end 1.6 0.8) (layer "F.Fab") (width 0.1))
     (pad "1" smd roundrect (at -1.7145 -0.0055 270) (size 1.143 1.789) (layers "F.Cu" "F.Paste" "F.Mask") (roundrect_rratio 0.2173910761)
