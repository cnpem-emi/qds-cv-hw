File: pcb/cad/qds-cv.kicad_pcb (KiCad board)
At the start: 4 copper layers, 0 parts

Commit message: Place components of +5V reference and detection circuits on PCB
Parts:
- added C201: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (161.3, 93.7)
- added C202: 330p, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (132.3, 97.8)
- added C203: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (161.3, 101.9)
- added C204: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (176.5, 97.3)
- added C205: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (185.2, 92.7)
- added C206: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (180.6, 101.8)
- added C207: 10u, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (136.4, 91.2)
- added C208: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (136.4, 103.9)
- added C209: 10u, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (144.5, 89.7)
- added C210: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (144.5, 91.7)
- added C211: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (182.9, 101.8)
- added C212: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (173.8, 81.7)
- added C213: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (186.8, 81.4)
- added C214: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (182.4, 74.8)
- added C601: 2.2u, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (254.4, 169.1)
- added C602: 470p, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (240.6, 172.5)
- added C604: 470p, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (244.8, 166.8)
- added C606: 470p, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (249.6, 166.8)
- added C607: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (261.5, 162.2)
- added C609: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (250.0, 169.6)
- added C613: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (254.4, 166.5)
- added C615: 470p, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (245.4, 169.8)
- added C701: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (165.9, 183.0)
- added C702: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (165.9, 178.0)
- added C703: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (152.4, 204.3)
- added C704: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (152.4, 201.8)
- added C801: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (172.0, 121.7)
- added C802: 2.2u, qds-cv-lib:CP_EIA-3528-21_AVX-B_Pad1.65x2.4mm_HandSolder, F.Cu at (139.0, 124.6)
- added C803: 1u, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (139.8, 127.9)
- added C804: 2.2u, qds-cv-lib:CP_EIA-3528-21_AVX-B_Pad1.65x2.4mm_HandSolder, F.Cu at (153.8, 128.1)
- added C805: 1u, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (158.1, 129.4)
- added D201: BAT54S, Package_TO_SOT_SMD:SOT-23, F.Cu at (132.3, 93.2)
- added D202: BAT54S, Package_TO_SOT_SMD:SOT-23, F.Cu at (132.3, 102.4)
- added D701: B220A, Diode_SMD:D_SMA_Handsoldering, F.Cu at (159.8, 199.6)
- added J201: Conn_Coaxial, qds-cv-lib:Molex_0731375003, F.Cu at (209.5, 113.3)
- added J701: Conn_Coaxial, qds-cv-lib:Molex_0731375003, F.Cu at (127.1, 189.6)
- added J702: DB9_Female, Connector_Dsub:DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Housed_MountingHolesOffset9.12mm, F.Cu at (157.5, 158.6)
- added K701: FINDER-30.22, Relay_THT:Relay_DPDT_Finder_30.22, F.Cu at (120.9, 202.5)
- added LD701: Red, qds-cv-lib:LED_WP934CB_ID, F.Cu at (190.4, 162.9)
- added LD702: Red, qds-cv-lib:LED_WP934CB_ID, F.Cu at (171.0, 183.9)
- added LD703: Red, qds-cv-lib:LED_WP934CB_ID, F.Cu at (159.3, 184.4)
- added LD704: Red, qds-cv-lib:LED_WP934CB_ID, F.Cu at (143.3, 193.8)
- added LD705: Red, qds-cv-lib:LED_WP934CB_ID, F.Cu at (150.3, 194.8)
- added Q701: BC846B, Package_TO_SOT_SMD:SOT-23, F.Cu at (137.9, 188.4)
- added R201: NP, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (128.3, 93.2)
- added R202: 2.49k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (176.5, 95.2)
- added R203: 47k, Resistor_SMD:R_0603_1608Metric_Pad0.98x0.95mm_HandSolder, F.Cu at (181.1, 92.7)
- added R204: 48.7k, Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder, F.Cu at (114.0, 96.3)
- added R205: 48.7k, Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder, F.Cu at (119.6, 96.3)
- added R206: 12, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (128.3, 96.3)
- added R207: 2.7k, Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder, F.Cu at (124.2, 100.8)
- added R208: 2.49k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (151.4, 96.5)
- added R209: 1.5k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (176.5, 101.3)
- added R210: 48.7k, Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder, F.Cu at (114.0, 99.3)
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Routing:
- net GND-ISO-A: track 0.00 -> 23.8 mm
- net +5V-ISO-A: track 0.00 -> 23.2 mm
- net +14V: track 0.00 -> 18.3 mm
- net Net-(U202-Pad7): track 0.00 -> 13.3 mm
- net Net-(U202-Pad6): track 0.00 -> 13.1 mm
- net Net-(R801-Pad1): track 0.00 -> 12.9 mm
- net Net-(C212-Pad1): track 0.00 -> 10.0 mm
- net Net-(C213-Pad1): track 0.00 -> 9.70 mm
- net Net-(C202-Pad2): track 0.00 -> 9.34 mm
- net Net-(C202-Pad1): track 0.00 -> 9.28 mm
- net /Detection validation/VAL-A: track 0.00 -> 8.76 mm
- net Net-(R205-Pad2): track 0.00 -> 8.73 mm
- net Net-(R207-Pad2): track 0.00 -> 8.67 mm
- net /Isolated detection channel A/V-DET: track 0.00 -> 8.36 mm
- net Net-(R202-Pad2): track 0.00 -> 8.14 mm
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- added copper zone on F.Cu, net Earth
Other:
- board outline added: 219 x 159 mm

Commit message: Place components of validation and quench trigger circuits on PCB
Parts:
- added C705: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (273.4, 134.3)
- U702: footprint Package_SO:TSSOP-20_4.4x6.5mm_P0.65mm -> Package_SO:SO-20_12.8x7.5mm_P1.27mm
- moved SW702 209.3 mm to (315.5, 69.5), turned to -90 degrees
- moved SW701 194.1 mm to (315.5, 81.3), turned to -90 degrees
- moved LD704 188.8 mm to (313.8, 112.5), turned to -90 degrees
- moved R701 188.2 mm to (308.2, 98.8)
- moved LD705 180.6 mm to (313.8, 118.0), turned to -90 degrees
- moved R711 178.6 mm to (307.3, 71.5), turned to 90 degrees
- moved LD703 172.8 mm to (313.8, 107.1), turned to -90 degrees
- moved LD702 164.8 mm to (313.8, 101.6), turned to -90 degrees
- moved R702 151.0 mm to (308.0, 104.1)
- moved R710 150.7 mm to (282.5, 145.5)
- moved R706 149.7 mm to (282.6, 137.5)
- moved R704 147.2 mm to (308.0, 115.1)
- moved R703 147.1 mm to (308.1, 109.6)
- moved U704 146.3 mm to (277.4, 139.7)
- moved C703 145.1 mm to (282.4, 139.7)
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Connections:
- LD701 pad 1: Net-(LD701-Pad1) -> Net-(U702-Pad19)
- LD702 pad 1: Net-(LD702-Pad1) -> Net-(U702-Pad18)
- LD703 pad 1: Net-(LD703-Pad1) -> Net-(U702-Pad17)
- LD704 pad 1: Net-(LD704-Pad1) -> Net-(U702-Pad16)
- LD705 pad 1: Net-(LD705-Pad1) -> Net-(U702-Pad15)
- RV601 pad 1: Net-(C601-Pad2) -> Net-(R601-Pad1)
- RV601 pad 3: Net-(R601-Pad1) -> Net-(C601-Pad2)
- U701 pad 10: Net-(U701-Pad10) -> Net-(U701-Pad11)
- U701 pad 12: Net-(U701-Pad12) -> Net-(U701-Pad6)
- U701 pad 13: /Quench trigger/SW_TRIG- -> Net-(U701-Pad3)
- U701 pad 6: Net-(U701-Pad10) -> Net-(U701-Pad6)
- U701 pad 8: Net-(U701-Pad12) -> Net-(U702-Pad7)
- U701 pad 9: Net-(U701-Pad3) -> /Quench trigger/SW_TRIG-
- U702 pad 14: Net-(LD705-Pad1) -> Net-(U703-Pad13)
- U702 pad 15: Net-(LD704-Pad1) -> Net-(U702-Pad15)
- U702 pad 16: Net-(LD703-Pad1) -> Net-(U702-Pad16)
- U702 pad 17: Net-(LD702-Pad1) -> Net-(U702-Pad17)
- U702 pad 18: Net-(LD701-Pad1) -> Net-(U702-Pad18)
- U702 pad 2: Net-(U701-Pad11) -> /Detection validation/TRIG-CH-A
- U702 pad 3: /Detection validation/TRIG-CH-A -> /Detection validation/TRIG-CH-B
- U702 pad 4: /Detection validation/TRIG-CH-B -> /Detection validation/TRIG-CH-C
- U702 pad 5: /Detection validation/TRIG-CH-C -> /Detection validation/TRIG-CH-D
- U702 pad 6: /Detection validation/TRIG-CH-D -> /Quench trigger/SW_TRIG-
- U702 pad 7: /Quench trigger/SW_TRIG- -> Net-(U702-Pad7)
- U703 pad 1: Net-(U701-Pad11) -> Net-(U702-Pad7)
- U703 pad 10: /Quench trigger/REMOTE_RST+ -> Net-(U703-Pad10)
- U703 pad 11: unconnected-(U703-Pad11) -> Net-(U703-Pad10)
- U703 pad 12: Earth -> Net-(U703-Pad3)
- U703 pad 13: Earth -> Net-(U703-Pad13)
- U703 pad 2: Net-(U701-Pad11) -> Net-(U702-Pad7)
- U703 pad 4: Net-(U703-Pad3) -> Earth
- U703 pad 5: Net-(U702-Pad19) -> Earth
- U703 pad 6: Net-(U703-Pad6) -> unconnected-(U703-Pad6)
- U703 pad 9: Net-(U703-Pad6) -> /Quench trigger/REMOTE_RST+
- U704 pad 1: Net-(U702-Pad19) -> Net-(U703-Pad13)
- U704 pad 3: Net-(U702-Pad19) -> Net-(U703-Pad13)
- U705 pad 1: Net-(U702-Pad19) -> Earth
- U705 pad 2: +5V -> Earth
- U705 pad 3: Earth -> Net-(U703-Pad13)
- U705 pad 4: unconnected-(U705-Pad4) -> Net-(R710-Pad1)
- U705 pad 5: Earth -> +5V
- U705 pad 6: Net-(R710-Pad1) -> unconnected-(U705-Pad6)
Routing:
- net Net-(U703-Pad13): track 0.00 -> 41.5 mm
- net /Detection validation/TRIG-CH-A: track 0.00 -> 30.3 mm
- net Net-(U702-Pad7): track 0.00 -> 29.8 mm
- net /Isolated detection channel A/V-DET: track 8.36 -> 37.7 mm
- net Net-(U702-Pad11): track 0.00 -> 28.4 mm
- net /+5V reference/+5VREF: track 3.80 -> 31.4 mm
- net /Detection validation/TRIG-CH-B: track 0.00 -> 21.3 mm
- net /Detection validation/TRIG-CH-C: track 0.00 -> 20.4 mm
- net /Detection validation/VAL-A: track 8.76 -> 29.0 mm
- net /Detection validation/TRIG-CH-D: track 0.00 -> 20.2 mm
- net Net-(U601-Pad1): track 0.00 -> 17.8 mm
- net /Quench trigger/SW_TRIG-: track 0.00 -> 16.7 mm
- net Net-(U601-Pad6): track 0.00 -> 14.6 mm
- net +5V: track 7.21 -> 21.5 mm
- net Net-(U601-Pad2): track 0.00 -> 10.3 mm
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