# Repository cnpem-emi/qds-cv-hw

File README.md:

# QDS-CV Hardware
Quench detection system for vertical cryostat.

## KiCad design pcb/cad/qds-cv.kicad_pcb

Board: 2 copper layers, 219.0 x 229.0 mm, 188 parts (26 on the bottom side), 94 nets.

Parts:
C201, C203, C204, C205, C206, C210, C211, C212, C213, C214, C607, C609, C613, C701, C702, C703, C704, C705, C801: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C202: 330p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C208: 100n; C_1206_3216Metric_Small_Pad
C209, C903, C905, C906, C915, C917, C923, C932: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C601: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C602, C604, C606, C615: 470p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C802, C804: 2.2u; CP_EIA-3528-21_AVX-B_Pad1.65x2.4mm_HandSolder
C803, C805, C902, C908, C910, C926, C935: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C901, C909, C925, C934: 22u; CP_EIA-6032-28_Kemet-C_Pad2.25x2.35mm_HandSolder
C904, C916, C918, C924, C927, C933, C936: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C907: 100u; C_Elec_6.3x7.7
D201, D202: BAT54S; SOT-23
D701: B220A; D_SMA_Handsoldering
D901: SMBJ15A; D_SMB
F901: Fuse; ZH242
J101: DB25 Female; DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_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
J102: Conn_01x08; PhoenixContact_MCV_1,5_6-GF-3.81_1x06_P3.81mm_Vertical_Thre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
J103: Conn_01x08; Edge_Pads-3.81_1x06_P3.81mm
J201, J301, J401, J501, J701: Conn_Coaxial; Molex_0731375003
J402: Conn_01x02; TerminalBlock_bornier-2_P5.08mm
J702: DB9_Female; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_H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
J901: Barrel_Jack_Switch; CUI_PJ-002AH
K701: FINDER-30.22; Relay_DPDT_Finder_30.22
LD701, LD702, LD703, LD704, LD705: Red; LED_WP934CB_ID
LD901: Green; LED_WP934CB_GD
PS901: JCM3012D15; JCM30
PS902: RI-1515S/P; RI-1515S
Q701: BC846B; SOT-23
R201: NP; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R202, R208: 2.49k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R203, R711, R905: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R204, R205, R210, R211: 48.7k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R206, R212: 12; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R207: 2.7k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R209, R214, R218: 1.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R213: 60.4k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R215, R219, R802, R804: 620; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R216, R601, R708, R709: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R217, R706: 49.9; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R602, R603, R604, R605, R710: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R606, R608, R610, R612, R803, R805: 20k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R701, R702, R703, R704, R705: 270; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R707: 180; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R712: 82; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R801: 14k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R901: 1.3k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R906: 4.42k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R908: 127k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R909: 12.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV201, RV801: 5k; Potentiometer_Bourns_3224X_Vertical
RV601: 50k; Potentiometer_Bourns_3224X_Vertical
SW601: SW_DIP_x04; SW_DIP_SPSTx04_Slide_6.7x11.72mm_W8.61mm_P2.54mm_LowProfile
SW701: RST; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
SW702: TRIG; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
TP101: VT1; TestPoint_Keystone_5010-5014_Multipurpose
TP102: VT2; TestPoint_Keystone_5010-5014_Multipurpose
TP103: TRIG-CH-A; TestPoint_Keystone_5010-5014_Multipurpose
TP104: TRIG-CH-B; TestPoint_Keystone_5010-5014_Multipurpose
TP105: TRIG-CH-C; TestPoint_Keystone_5010-5014_Multipurpose
TP106: TRIG-CH-D; TestPoint_Keystone_5010-5014_Multipurpose
TP107: +15V; TestPoint_Keystone_5010-5014_Multipurpose
TP108: -14V; TestPoint_Keystone_5010-5014_Multipurpose
TP109: +14V; TestPoint_Keystone_5010-5014_Multipurpose
TP110: +5V; TestPoint_Keystone_5010-5014_Multipurpose
TP111: +5V-ISO-A; TestPoint_Keystone_5010-5014_Multipurpose
TP112, TP113: GND-ISO-A; TestPoint_Keystone_5010-5014_Multipurpose
TP116, TP117, TP118, TP119, TP120, TP121: GND; TestPoint_Keystone_5010-5014_Multipurpose
TP201: Vth-H; TestPoint_Keystone_5010-5014_Multipurpose
TP202: Vth-L; TestPoint_Keystone_5010-5014_Multipurpose
TP203: V-VAL; TestPoint_Keystone_5010-5014_Multipurpose
TP204: Vdiff1+; TestPoint_Keystone_5010-5014_Multipurpose
TP205: Vdiff1-; TestPoint_Keystone_5010-5014_Multipurpose
TP206: Vdiff2+; TestPoint_Keystone_5010-5014_Multipurpose
TP207: Vdiff2-; TestPoint_Keystone_5010-5014_Multipurpose
TP208: Vsing; TestPoint_Keystone_5010-5014_Multipurpose
TP209: V-DET; TestPoint_Keystone_5010-5014_Multipurpose
TP301: RCx; TestPoint_Keystone_5010-5014_Multipurpose
TP501: 5V-REF; TestPoint_Keystone_5010-5014_Multipurpose
TP701: FF-CLK; TestPoint_Keystone_5010-5014_Multipurpose
TP702: Q-TRIG; TestPoint_Keystone_5010-5014_Multipurpose
U201, U801: OPA2227; SOIC-8_3.9x4.9mm_P1.27mm
U202: AMC1200; SOP-8_6.62x9.15mm_P2.54mm
U203: AD8421; SOIC-8_3.9x4.9mm_P1.27mm
U204: LM393-N; SOIC-8_3.9x4.9mm_P1.27mm
U601: 74HC32D; SO-14_3.9x8.65mm_P1.27mm
U602: 74HC123; SOIC-16_3.9x9.9mm_P1.27mm
U603, U701: 74HCS08; SO-14_3.9x8.65mm_P1.27mm
U702: 74HC573; SO-20_12.8x7.5mm_P1.27mm
U703: 74LV132; SO-14_3.9x8.65mm_P1.27mm
U704, U705: 74LVC2G17; SOT-23-6_Handsoldering
U706: HFBR-1521Z
U802: MAX6350CSA; SOIC-8_3.9x4.9mm_P1.27mm
U901: LT1129CST-5; SOT-223-3_TabPin2
U903: R-78E5.0-0.5; Converter_DCDC_RECOM_R-78E-0.5_THT
U905: LT1965EMS8E_PBF; SOP65P490X110-9N
U907: LT3015EMSEPBF; MSOP-12_MSE

Connections:
+5V: C209.1, C210.1, C607.1, C609.1, C613.1, C701.1, C702.1, C703.1, C704.1, C705.2, C917.1, C918.1, J102.6, J103.6, LD701.2 (A), LD702.2 (A), LD703.2 (A), LD704.2 (A), LD705.2 (A), R215.2, R216.1, R601.2, R602.2, R603.2, R604.2, R605.2, R708.1, R709.1, TP110.1, U202.8 (V2+), U601.14 (VCC), U602.2 (B), U602.3 (Clr), U602.16 (VCC), U603.14 (VCC), U701.14 (VCC), U702.20 (VCC), U703.14 (VCC), U704.5 (VCC), U705.5 (VCC), U903.3 (OUT)
+5V-ISO-A: C208.1, C906.1, D201.2, D202.2, R201.2, TP111.1, U202.1 (V1+), U901.3 (VO)
+14V: C201.1, C205.1, C214.1, C801.1, C802.1, C925.1, C926.1, C927.1, J102.4, J103.4, R803.2, R905.1, TP109.1, U201.8 (V+), U203.8 (Vs+), U204.8 (V+), U801.8 (V+), U802.2 (IN), U905.1 (OUT), U905.2 (OUT)
+15V: C901.1, C902.1, C903.1, C904.1, C915.1, C916.1, C923.1, C924.1, J102.1, J103.1, PS901.4 (+VOUT), PS902.2 (+VIN), R707.1, TP107.1, U903.1 (IN), U905.6 (~SHDN), U905.7 (IN), U905.8 (IN)
-14V: C203.1, C206.2, C934.1, C935.1, C936.1, J102.3, J103.3, R908.1, TP108.1, U201.4 (V-), U203.5 (Vs-), U907.9 (OUT_2), U907.10 (OUT_3), U907.11 (OUT_4), U907.12 (OUT)
-15V: C909.2, C910.2, C932.1, C933.1, PS901.6 (-VOUT), U907.1 (IN_2), U907.2 (IN_3), U907.3 (IN_4), U907.4 (IN), U907.5 (*SHDN), U907.13 (EPAD)
/+5V reference/+5VREF: R213.1, R802.2, TP501.1, U801.1
/Detection validation/TRIG-CH-A: C602.1, R606.2, SW601.4, TP103.1, U701.1, U702.2 (D0)
/Detection validation/TRIG-CH-B: C604.1, R608.2, SW601.3, TP104.1, U701.2, U702.3 (D1)
/Detection validation/TRIG-CH-C: C606.1, R610.2, SW601.2, TP105.1, U701.4, U702.4 (D2)
/Detection validation/TRIG-CH-D: C615.1, R612.2, SW601.1, TP106.1, U701.5, U702.5 (D3)
/Detection validation/VAL-A: R216.2, TP203.1, U204.1, U204.7, U601.5, U602.1 (A)
/Isolated detection channel A/V-DET: R203.2, TP209.1, U201.1, U204.2 (-), U204.5 (+)
/Quench trigger/ILOCK_11: J702.5, K701.11
/Quench trigger/ILOCK_12: J702.9, K701.14
/Quench trigger/ILOCK_21: J702.4, K701.21
/Quench trigger/ILOCK_22: J702.8, K701.24
/Quench trigger/REMOTE_RST+: J702.7, R708.2, SW701.2, U703.10
/Quench trigger/SW_TRIG+: J702.1, R709.2
/Quench trigger/SW_TRIG-: J702.2, R711.1, SW702.2, U701.9, U702.6 (D4)
/VT1: J101.9, J101.21, R204.1, TP101.1
/VT2: J101.12, J101.24, R210.1, TP102.1
/VT3: J101.5, J101.18
/VT4: J101.2, J101.15
Earth: C201.2, C203.2, C204.2, C205.2, C206.1, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C601.1, C602.2, C604.2, C606.2, C607.2, C609.2, C613.2, C615.2, C701.2, C702.2, C703.2, C704.2, C705.1, C801.2, C802.2, C803.2, C804.2, C805.2, C901.2, C902.2, C903.2, C904.2, C909.1, C910.1, C915.2, C916.2, C917.2, C918.2, C923.2, C924.2, C925.2, C926.2, C927.2, C932.2, C933.2, C934.2, C935.2, C936.2, J101.0 (PAD), J102.2, J102.5, J103.2, J103.5, J201.2 (Ext), J701.2 (Ext), J702.0 (PAD), J702.6, LD901.1 (K), PS901.5 (COMMON), PS902.1 (-VIN), Q701.2 (E), R202.1, R219.1, R608.1, R610.1, R612.1, R711.2, R805.1, R906.2, R909.2, RV801.2, RV801.3, SW701.1, SW702.1, TP116.1, TP117.1, TP118.1, TP119.1, TP120.1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
GND-ISO-A: C208.2, C905.2, C906.2, D201.1, D202.1, PS902.3 (-VOUT), R207.2, R211.2, R212.1, R901.2, TP112.1, TP113.1, U202.4 (V1-), U901.2 (GND)
unnamed: C202.1, D201.3, R201.1, R206.2, TP204.1, U202.2 (+)
unnamed: C202.2, D202.3, R212.2, TP205.1, U202.3 (-)
unnamed: C204.1, R209.2, R213.2, U201.3 (+)
unnamed: C211.1, R218.2, U201.5 (+)
unnamed: C212.1, R215.1, RV201.2, TP201.1, U204.3 (+)
unnamed: C213.1, R219.2, RV201.3, TP202.1, U204.6 (-)
unnamed: C601.2, RV601.3, TP301.1, U602.15 (RCx)
unnamed: C803.1, U802.3 (NR)
unnamed: C804.1, R804.1, U802.6 (OUT)
unnamed: C805.1, R804.2, U801.3 (+)
unnamed: C905.1, PS902.4 (+VOUT), R901.1, U901.1 (VI)
unnamed: C907.1, C908.1, D901.1 (A1), F901.2, PS901.1 (+VIN), PS901.3 (REMOTE_ON/OFF)
unnamed: C907.2, C908.2, D901.2 (A2), J402.2, J901.2, PS901.2 (-VIN)
unnamed: D701.1 (K), K701.A1, R707.2
unnamed: D701.2 (A), K701.A2, Q701.3 (C)
unnamed: F901.1, J402.1, J901.1
unnamed: J201.1 (In), R217.2
unnamed: J701.1 (In), R706.2
unnamed: LD701.1 (K), R701.1
unnamed: LD702.1 (K), R702.1
unnamed: LD703.1 (K), R703.1
unnamed: LD704.1 (K), R704.1
unnamed: LD705.1 (K), R705.1
unnamed: Q701.1 (B), R710.2
unnamed: R202.2, R203.1, U201.2 (-)
unnamed: R204.2, R205.1
unnamed: R205.2, R206.1, R207.1
unnamed: R208.1, U203.3 (Rg)
unnamed: R208.2, U203.2 (Rg)
unnamed: R209.1, R218.1, TP208.1, U203.7
unnamed: R210.2, R211.1
unnamed: R214.1, U201.6 (-)
unnamed: R214.2, R217.1, U201.7
unnamed: R601.1, RV601.1, RV601.2
unnamed: R602.1, SW601.5
unnamed: R603.1, SW601.6
unnamed: R604.1, SW601.7
unnamed: R605.1, SW601.8
unnamed: R606.1, U603.3
unnamed: R701.2, U702.19 (Q0)
unnamed: R702.2, U702.18 (Q1)
unnamed: R703.2, U702.17 (Q2)
unnamed: R704.2, U702.16 (Q3)
unnamed: R705.2, U702.15 (Q4)
unnamed: R706.1, U705.4
unnamed: R710.1, U704.4
unnamed: R712.1, U704.6
unnamed: R712.2, U706.1 (Anode)
unnamed: R801.1, RV801.1
unnamed: R801.2, R802.1, U801.2 (-)
unnamed: R803.1, R805.2, U801.5 (+)
unnamed: R905.2, R906.1, U905.3 (ADJ)
unnamed: R908.2, R909.1, U907.8 (SENSE/ADJ)
unnamed: TP206.1, U202.7 (+), U203.1 (-)
unnamed: TP207.1, U202.6 (-), U203.4 (+)
unnamed: TP701.1, U702.11 (Cp), U703.8
unnamed: TP702.1, U702.14 (Q5), U703.5, U704.1, U704.3, U705.3
unnamed: U601.1, U601.4, U602.13 (Q)
unnamed: U601.2, U602.4 (~Q)
unnamed: U601.3, U603.1
unnamed: U601.6, U603.2
unnamed: U701.8, U702.7 (D5), U703.1, U703.2
unnamed: U701.10, U701.11
unnamed: U701.6, U701.12
unnamed: U701.3, U701.13
unnamed: U703.3, U703.4
unnamed: U703.6, U703.9
unnamed: U801.6 (-), U801.7

## Commit log

2023-02-27 spice simulations added
2023-03-08 Include subcircuits and symbols to library and simulations of conditioning circuit
2023-03-15 updating simulations and library, output files directory renamed to "out"
2023-03-16 Updated input resistors from isolated front-end circuit simulation model
2023-03-17 Create KiCad project
2023-03-17 Ignore KiCad backups
2023-03-17 Included project field name templates
2023-03-17 Define sheet hierarchy and title block
2023-03-17 Remove auto_save_files and included custom rules file
2023-03-17 Included design rules for LPKF and JLCPCB and 4-layer board stack-up
2023-03-20 create symbol library for KiCad schematic
2023-03-20 new symbols, footprints and 3d models added to project's library
2023-03-21 Analog front-end schematic created
2023-03-21 Power supplies schematic created
2023-03-21 Comparator circuit included on the front-end sheet
2023-03-22 Included power supplies circuits and +5V-REF RC circuit in analog front-end
2023-03-23 Validation schematic created
2023-03-23 update component values in simulation files
2023-03-24 specify components used in front-end, validation and power circuits, except resistors
2023-03-29 create schematic for trigger aggregation, indication and actuation circuits
2023-03-29 Created hierarchy connections, updates on analog-front-end and included 5V reference circuit
2023-03-30 update components specification
2023-03-31 Update componentes fields and reference circuit
2023-03-31 replace 4k7 resistors part number
2023-04-01 Fixed footprints 3D models orientation
2023-04-01 Update power supplies, symbols and footprint libs
2023-04-01 Grouped 74HC123 into two IC's and updated BNC connector 3D model
2023-04-04 Fix +5V power reference so it is connected to R-78E5 output
2023-04-04 Replace schematic symbols and text fields for a better view
2023-04-05 Make modifications needed for single channel board
2023-04-06 Add test points and extra resistors for temporary use. Remove power supplies
2023-04-06 Place components of +5V reference and detection circuits on PCB
2023-04-06 Place components of validation and quench trigger circuits on PCB
2023-04-10 Move schematic symbols and text fields for a better view
2023-04-10 Include ISO-A power circuit, all connectors and test points on PCB
2023-04-11 Fix U705 supply voltage, add decoupling capacitor and remove unused parts - close #1 - close #2 - close #3
2023-04-11 Fix isolated supplies from analog-front-end, include no-connection flags, move itens in root sheet for better view, redefine pin types to fix ERC
2023-04-11 Remake some logic connections and update PCB
2023-04-13 Last commit before flipping PTH components
2023-04-13 Flip PTH components to reduce vias
2023-04-14 Update PCB layout
2023-04-17 Finish routing
2023-04-19 Include pdf file for schematics, remove pdf files from gitignore, delete template pdf file
2023-04-19 Finish PCB layout including revision close #9 close #10 close #11 close #12 close #13 close #14 close #15 close #16
2023-04-19 Plot gerber files, export schematic in PDF
2023-04-24 Assign test point values, arrange PCB fabrication layers
2023-04-25 Rectify 74574 partnumber, generate HTML BOM list
2023-04-26 Increase value of resistor in series with relay coil (R707)
2023-04-26 Several updates on schematic - close #5, close #6, close #7, close #8. - include test points - change relay supply to 15V and its series resistor to 180 ohm - replace AMC1200 VDD1 capacitor of 100nF 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
2023-04-26 Start PCB design based on 1-channel version layout
2023-04-27 Preliminary placement of components from detection to validation stages
2023-05-03 Include resistors tied to +5V and GND in isolated front-end circuits
2023-05-04 Reposition of channels and connectors, place and route trigger and actuation circuit
2023-05-08 Replicate detection layout for all channels, place and route 5V-REF circuit
2023-05-09 Create +14V, -14V, +5V copper zones
2023-05-10 Improve window comparator, +5V-REF and relay driver circuits close #19 close #20 close #22
2023-05-10 Apply several changes based on test results - replace validation time 4k7 resistor by a 8k2, close #21 - remove pull-up resistor from AMC1200 positive input - split voltage taps pull-up/down resistor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
2023-05-12 Set board stack-up according to JLCPCB specifications
    Specifications were obtained in https://jlcpcb.com/impedance for the following requirements:
    - 4-layer PCB with 1.6 mm thickness
    - 1 oz outer copper weight
    - 0.5 oz inner copper weight
    - "No requirement" stackup
    - Outer layer copper thickness: 0.035 mm
2023-05-12 Add stitching capacitors to isolated supply circuits
2023-05-15 Route front-end voltage taps
2023-05-16 Place test-points, improve isolated circuit layout (channel D only)
2023-05-16 Define JLCPCB manufacturing rules
2023-05-16 Increase DB-25 shield connection, place fiducials close #30
2023-05-16 Replicate front-end layout from channel D to others close #24 close #25 close #26 close #27 close #28
2023-05-17 Finish routing close #18
2023-05-17 Design silkscreen layers
2023-05-17 Place stitching vias on board edge, close #29
2023-05-18 Improve power supply heat sink, copper areas and footprints close #32 close #33 close #34 close #36
2023-05-18 Increase +12V input tracks to 2 mm close #35
2023-05-18 Move JCM3012 closer to power input
2023-05-19 Restore power supply circuit and make a separate board for it
2023-05-22 Replace C211 capacitor with a 0805 model close #37
2023-05-22 Include fiducials on bottom layer close #39
2023-05-22 Increase JCM30 pads size close #40
2023-05-22 Reduce LDOs thermal vias size close #41
2023-05-23 Remove loops from inner planes, relocate test points close #42
2023-05-23 Make solid connections between U903 pads and inner planes close #43
2023-05-23 Improve U903 connection to +15V plane close #44
2023-05-23 Remove solder mask covering thermal pads close #47
2023-05-23 Include all 3D models in project's library close #45
2023-05-23 Apply KiCAD cleanup tools
2023-05-23 Correct C934 polarization, rearrange JCM3012 Vin capacitors
2023-05-24 Include 3D model for Hammond enclosure
2023-05-24 Fill out inner layers with supply planes
2023-05-24 Move POF signal track to top, increase -15V dissipation plane on botton
2023-05-24 Improve reset and sw_trigger circuits - add RC filter for reset signal (R713, C706) - change values of sw-trigger pull-up/down resistors (R709, R711) and add capacitor (C707)
2023-05-26 Include information on silkscreen close #38
2023-05-26 Make solid connections between PS901 and inner planes
2023-05-29 Update component values on RST circuit, cleanup tracks
2023-05-29 Update schematic PDF, update readme
2023-05-29 Export gerbers
2023-06-05 Create 3D model with Hammond enclosure and end panels
2023-06-07 Generate gerbers of side panels
2023-07-25 Replace protection flip-flop with latch, update components description generate HTML BOM list.
2023-08-09 Create mechanical files for enclosure side panels
2023-09-26 Replace tantalum capacitor symbols with polarized version
2023-09-26 Update component properties
2023-09-26 Replace tantalum capacitor symbols with polarized version close #51
2023-09-26 Replace 74574 flip-flop with 74573 latch close #48
2023-09-28 Include SPICE simulations for LTSPICE and TINA
    - Broken-wire detection circuit
    - Input overvoltage protection
    - Pertubation on external SW trigger interface
    - AMC1200 (IsoAmp) CMRR and noise analysis
    - BNC monitor noise
2024-02-28 Simulation for proposed scheme to fix broken wire detection
2024-02-28 Remove useless simulation output files
2024-02-28 Update simulation README, ignore simulation output files
