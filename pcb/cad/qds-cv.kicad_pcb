File: pcb/cad/qds-cv.kicad_pcb (KiCad board)
At the start: 4 copper layers, 219 x 159 mm, 125 parts, among them J101 DB25 Female, J102 Conn_01x08, J201 Conn_Coaxial, J301 Conn_Coaxial, J401 Conn_Coaxial, J501 Conn_Coaxial, J701 Conn_Coaxial, J702 DB9_Female, J901 Barrel_Jack_Switch, K701 FINDER-30.22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

Commit message: Last commit before flipping PTH components
Parts:
- removed C207: 10u, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
- added TP101: VT1, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (121.4, 122.7)
- added TP102: VT2, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (121.4, 135.1)
- added TP103: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (282.2, 173.7)
- added TP104: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (282.2, 168.7)
- added TP105: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (282.2, 163.3)
- added TP106: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (282.2, 158.2)
- added TP107: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (191.3, 81.0)
- added TP108: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (198.1, 81.0)
- added TP109: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (205.2, 81.0)
- added TP110: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (212.6, 81.0)
- added TP111: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (133.9, 137.2)
- added TP112: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (143.0, 148.3)
- added TP113: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (137.9, 153.7)
- added TP114: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (143.3, 153.7)
- added TP115: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (138.0, 148.3)
- added TP116: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (168.4, 181.4)
- added TP117: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (176.5, 181.2)
- added TP118: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (176.5, 191.3)
- added TP119: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (168.4, 191.3)
- added TP201: Vth-H, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (193.5, 143.8)
- added TP202: Vth-L, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (203.5, 143.8)
- added TP203: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (213.1, 137.4)
- added TP204: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (131.1, 122.7)
- added TP205: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (138.9, 137.2)
- added TP206: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (164.6, 121.4)
- added TP207: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (163.8, 137.4)
- added TP208: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (171.4, 140.2)
- added TP209: V-DET, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (190.5, 123.2)
- added TP301: RCx, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (219.7, 114.8)
- added TP501: 5V-REF, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (172.0, 121.4)
- added TP701: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (277.9, 115.8)
- added TP702: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (281.7, 151.9)
- C208: footprint Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder -> Capacitor_SMD:C_1206_3216Metric
- C903, C904, C905, C906, D201, D202, R901, U901: moved to B.Cu
- moved J102 64.6 mm to (194.4, 89.8)
- moved C702 39.6 mm to (257.7, 80.8), turned to 0 degrees
- moved R608 33.3 mm to (250.1, 118.9)
- moved R708 33.1 mm to (269.5, 112.3), turned to -90 degrees
- moved U701 32.7 mm to (260.7, 86.3), turned to 90 degrees
- moved C701 31.7 mm to (270.3, 108.7), turned to 0 degrees
- moved R612 31.5 mm to (250.1, 107.6)
- moved R604 31.5 mm to (235.3, 98.5)
- moved R605 31.5 mm to (235.3, 101.0)
- moved R606 31.5 mm to (240.5, 118.7)
- moved C705 31.5 mm to (270.0, 92.6)
- moved R602 31.5 mm to (235.3, 93.2)
- moved SW601 31.5 mm to (245.0, 98.5)
- moved U603 31.5 mm to (239.2, 125.6)
- moved U702 31.5 mm to (261.9, 98.3)
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Connections:
- J102 pad 5: +15V -> Earth
- J102 pad 6: unconnected-(J102-Pad6) -> +15V
- RV801 pad 1: Earth -> Net-(R801-Pad1)
- RV801 pad 2: Net-(R801-Pad1) -> Earth
- RV801 pad 3: Net-(R801-Pad1) -> Earth
- SW601 pad 1: unconnected-(SW601-Pad1) -> /Detection validation/TRIG-CH-D
Routing:
- net Net-(J201-Pad1): track 133.4 -> 0.00 mm
- net GND-ISO-A: track 53.3 -> 81.9 mm, vias 0 -> 1
- net /VT2: track 19.9 -> 3.41 mm
- net /VT1: track 17.7 -> 3.91 mm
- net /Isolated detection channel A/V-DET: track 31.5 -> 18.5 mm
- net /+5V reference/+5VREF: track 23.2 -> 11.6 mm
- net Net-(R209-Pad1): track 21.8 -> 11.9 mm
- net /Detection validation/TRIG-CH-A: track 54.5 -> 45.7 mm
- net /Detection validation/VAL-A: track 48.6 -> 40.1 mm
- net Net-(C202-Pad2): track 9.34 -> 17.6 mm, vias 0 -> 1
- net +5V-ISO-A: track 28.9 -> 36.9 mm, vias 0 -> 1
- net /Detection validation/TRIG-CH-D: track 39.4 -> 31.6 mm
- net Net-(C905-Pad1): track 9.56 -> 17.1 mm
- net Net-(U701-Pad8): track 27.6 -> 34.9 mm
- net /Detection validation/TRIG-CH-C: track 47.2 -> 40.4 mm
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- added copper zone on B.Cu, net Earth
Other:
- copper layers 4 -> 2

Commit message: Flip PTH components to reduce vias
Parts:
- J101, J201, J301, J401, J501, J701, J702, J901, K701, LD701, LD702, LD703, LD704, LD705, LD901, SW701, SW702, U706: moved to B.Cu
- moved J901 137.7 mm to (308.9, 185.8)
- moved U706 135.4 mm to (101.9, 183.9), turned to 90 degrees
- moved J501 130.6 mm to (306.0, 54.6), turned to 90 degrees
- moved LD901 119.9 mm to (314.6, 177.2), turned to 90 degrees
- moved J101 114.8 mm to (110.6, 60.3), turned to 90 degrees
- moved SW702 99.9 mm to (316.3, 168.6), turned to 90 degrees
- moved J401 95.5 mm to (306.0, 72.1), turned to 90 degrees
- moved SW701 78.0 mm to (316.3, 158.5), turned to 90 degrees
- moved K701 67.5 mm to (127.2, 150.4), turned to -90 degrees
- moved J702 63.5 mm to (111.1, 148.4), turned to 90 degrees
- moved J301 60.3 mm to (306.1, 89.7), turned to 90 degrees
- moved D701 55.4 mm to (123.5, 143.3)
- moved R711 46.8 mm to (263.4, 57.1)
- moved R707 46.0 mm to (122.9, 138.4), turned to -90 degrees
- moved Q701 46.0 mm to (126.5, 138.4), turned to -90 degrees
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Connections:
- D701 pad 1: Net-(D701-Pad1) -> Net-(LD702-Pad1)
- K701 pad A1: Net-(D701-Pad1) -> Net-(LD702-Pad1)
- Q701 pad 3: Net-(D701-Pad2) -> Net-(LD702-Pad1)
- R707 pad 2: Net-(D701-Pad1) -> Net-(D701-Pad2)
Routing:
- net /Detection validation/TRIG-CH-A: track 45.7 -> 60.4 mm
- net /Quench trigger/SW_TRIG+: track 14.0 -> 0.00 mm
- net Net-(LD702-Pad1): track 0.00 -> 11.8 mm, vias 0 -> 1
- net Net-(D701-Pad1): track 9.64 -> 0.00 mm
- net /Quench trigger/ILOCK_12: track 30.9 -> 37.1 mm
- net Net-(LD705-Pad2): track 4.96 -> 0.00 mm
- net Net-(LD704-Pad2): track 4.84 -> 0.00 mm
- net Net-(LD702-Pad2): track 4.84 -> 0.00 mm
- net Net-(LD703-Pad2): track 4.71 -> 0.00 mm
- net Net-(LD701-Pad2): track 4.58 -> 0.00 mm
- net Net-(D701-Pad2): track 10.3 -> 12.4 mm, vias 0 -> 1
