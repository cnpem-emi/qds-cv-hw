File: pcb/cad/qds-cv.kicad_pcb (KiCad board)
At the start: 4 copper layers, 219 x 159 mm, 114 parts, among them J201 Conn_Coaxial, J701 Conn_Coaxial, J702 DB9_Female, K701 FINDER-30.22, Q701 BC846B, SW601 SW_DIP_x05, SW701 RST, SW702 TRIG, U201 OPA2227, U202 AMC1200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

Commit message: Include ISO-A power circuit, all connectors and test points on PCB
Parts:
- removed R222: 0, Resistor_SMD:R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
- removed R223, R224: 0, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- added C903: 10u, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (143.0, 152.6)
- added C904: 100n, Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder, F.Cu at (140.7, 152.4)
- added C905: 10u, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (140.5, 147.0)
- added C906: 10u, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, F.Cu at (147.5, 153.7)
- added J101: DB25 Female, Connector_Dsub:DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Housed_MountingHolesOffset9.12mm, F.Cu at (110.9, 175.1)
- added J102: Conn_01x08, Connector_Phoenix_MC:PhoenixContact_MCV_1,5_6-GF-3.81_1x06_P3.81mm_Vertical_ThreadedFlange, F.Cu at (168.7, 90.3)
- added J301: Conn_Coaxial, qds-cv-lib:Molex_0731375003, F.Cu at (306.3, 154.0)
- added J401: Conn_Coaxial, qds-cv-lib:Molex_0731375003, F.Cu at (306.2, 169.7)
- added J501: Conn_Coaxial, qds-cv-lib:Molex_0731375003, F.Cu at (306.3, 185.4)
- added J901: Barrel_Jack_Switch, qds-cv-lib:CUI_PJ-002AH, F.Cu at (305.3, 48.1)
- added LD901: Green, qds-cv-lib:LED_WP934CB_GD, F.Cu at (314.6, 58.9)
- added PS902: RI-1515S/P, qds-cv-lib:RI-1515S, F.Cu at (134.6, 149.9)
- added R901: 1.3k, Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder, F.Cu at (143.3, 147.0)
- added TP101: VT1, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (163.1, 106.9)
- added TP102: VT2, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (183.3, 102.6)
- added TP103: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (168.1, 101.9)
- added TP104: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (183.3, 97.6)
- added TP105: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (168.1, 96.8)
- added TP106: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (198.4, 87.5)
- added TP107: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (168.1, 106.9)
- added TP108: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (178.2, 96.8)
- added TP109: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (203.4, 92.5)
- added TP110: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (178.2, 106.9)
- added TP111: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (198.4, 92.5)
- added TP112: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (188.3, 96.8)
- added TP113: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (173.2, 101.9)
- added TP114: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (163.1, 101.9)
- added TP115: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (173.2, 106.9)
- added TP116: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (163.1, 96.8)
- added TP117: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (203.4, 87.5)
- added TP118: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (178.2, 101.9)
- added TP119: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (173.2, 96.8)
- added TP201: Vth-H, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (163.1, 72.5)
- added TP202: Vth-L, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (168.1, 72.5)
- added TP203: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (183.3, 72.5)
- added TP204: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (168.1, 77.5)
- added TP205: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (178.2, 72.5)
- added TP206: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (163.1, 77.5)
- added TP207: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (173.2, 77.5)
- added TP208: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (173.2, 72.5)
- added TP209: V-DET, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (178.2, 77.5)
- added TP301: RCx, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (215.5, 72.5)
- added TP501: 5V-REF, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose, F.Cu at (211.7, 98.8)
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Connections:
- R202 pad 1: Net-(R202-Pad1) -> Earth
- R207 pad 1: Net-(R207-Pad1) -> Net-(R205-Pad2)
- R208 pad 1: Net-(R208-Pad1) -> Net-(U203-Pad3)
- SW601 pad 1: /Detection validation/TRIG-CH-A -> unconnected-(SW601-Pad1)
- SW601 pad 10: Net-(R602-Pad1) -> unconnected-(SW601-Pad10)
- SW601 pad 2: /Detection validation/TRIG-CH-B -> /Detection validation/TRIG-CH-D
- SW601 pad 4: /Detection validation/TRIG-CH-D -> /Detection validation/TRIG-CH-B
- SW601 pad 5: unconnected-(SW601-Pad5) -> /Detection validation/TRIG-CH-A
- SW601 pad 6: unconnected-(SW601-Pad6) -> Net-(R602-Pad1)
- SW601 pad 7: Net-(R605-Pad1) -> Net-(R603-Pad1)
- SW601 pad 9: Net-(R603-Pad1) -> Net-(R605-Pad1)
- U203 pad 3: Net-(R223-Pad2) -> Net-(U203-Pad3)
Routing:
- net /+5V reference/+5VREF: track 31.4 -> 3.80 mm
- net /Detection validation/TRIG-CH-B: track 21.3 -> 44.2 mm
- net /Detection validation/TRIG-CH-C: track 20.4 -> 37.3 mm
- net /Detection validation/TRIG-CH-A: track 30.3 -> 46.5 mm
- net Net-(R209-Pad1): track 0.00 -> 11.7 mm
- net /Detection validation/TRIG-CH-D: track 20.2 -> 28.8 mm
- net /Isolated detection channel A/V-DET: track 37.7 -> 31.5 mm
- net Net-(U202-Pad6): track 13.1 -> 8.42 mm
- net Net-(U202-Pad7): track 13.3 -> 8.65 mm
- net Net-(R223-Pad2): track 4.61 -> 0.00 mm
- net Net-(C202-Pad1): track 9.28 -> 13.2 mm
- net Net-(U203-Pad3): track 0.00 -> 3.48 mm
- net Net-(R207-Pad1): track 3.02 -> 0.00 mm
- net Net-(R801-Pad1): track 12.9 -> 10.3 mm
- net Net-(R205-Pad2): track 8.73 -> 6.16 mm
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
Commit message: Remake some logic connections and update PCB
Parts:
- removed TP101: VT1, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose
- removed TP102: VT2, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose
- removed TP103, TP104, TP105, TP106, TP107, TP108, TP109, TP110, TP111, TP112, TP113, TP114, TP115, TP116, TP117, TP118, TP119, TP203, TP204, TP205, TP206, TP207, TP208, TP701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: TestPoint, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose
- removed TP201: Vth-H, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose
- removed TP202: Vth-L, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose
- removed TP209: V-DET, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose
- removed TP301: RCx, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose
- removed TP501: 5V-REF, qds-cv-lib:TestPoint_Keystone_5010-5014_Multipurpose
- moved R709 184.3 mm to (119.9, 92.5), turned to 90 degrees
- moved J102 88.1 mm to (251.0, 58.8)
- moved R708 63.3 mm to (283.4, 142.3), turned to 180 degrees
- moved C701 30.0 mm to (282.2, 138.1), turned to -90 degrees
- moved U703 26.1 mm to (277.1, 141.0)
- moved C208 22.9 mm to (149.1, 152.3)
- moved C803 22.9 mm to (165.0, 124.6)
- moved C804 22.9 mm to (179.7, 121.6)
- moved PS902 22.9 mm to (136.0, 127.0)
- moved C201 22.9 mm to (169.5, 142.3)
- moved C202 22.9 mm to (145.1, 146.2)
- moved C203 22.9 mm to (169.5, 150.4)
- moved C204 22.9 mm to (178.8, 146.9)
- moved C205 22.9 mm to (187.5, 142.3)
- moved C206 22.9 mm to (182.9, 151.4)
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Connections:
- R207 pad 2: Net-(R207-Pad2) -> GND-ISO-A
- R211 pad 2: Net-(R207-Pad2) -> GND-ISO-A
- R212 pad 1: Net-(R207-Pad2) -> GND-ISO-A
- U702 pad 14: Net-(U702-Pad14) -> Net-(TP702-Pad1)
- U703 pad 10: Net-(U703-Pad10) -> /Quench trigger/REMOTE_RST+
- U703 pad 11: Net-(U703-Pad10) -> unconnected-(U703-Pad11)
- U703 pad 12: Net-(U703-Pad12) -> Earth
- U703 pad 13: Net-(U702-Pad14) -> Earth
- U703 pad 3: Net-(U703-Pad12) -> Net-(U703-Pad3)
- U703 pad 4: Earth -> Net-(U703-Pad3)
- U703 pad 5: Earth -> Net-(TP702-Pad1)
- U703 pad 6: unconnected-(U703-Pad6) -> Net-(U703-Pad6)
- U703 pad 9: /Quench trigger/REMOTE_RST+ -> Net-(U703-Pad6)
- U704 pad 1: Net-(U702-Pad14) -> Net-(TP702-Pad1)
- U704 pad 3: Net-(U702-Pad14) -> Net-(TP702-Pad1)
- U705 pad 3: Net-(U702-Pad14) -> Net-(TP702-Pad1)
Routing:
- net Net-(J201-Pad1): track 0.00 -> 133.4 mm
- net Net-(U702-Pad14): track 40.3 -> 0.00 mm
- net Net-(TP702-Pad1): track 0.00 -> 34.9 mm
- net /Quench trigger/ILOCK_12: track 0.00 -> 30.9 mm
- net GND-ISO-A: track 23.8 -> 53.3 mm
- net /VT2: track 0.00 -> 19.9 mm
- net /Detection validation/VAL-A: track 29.0 -> 48.6 mm
- net /+5V reference/+5VREF: track 3.80 -> 23.2 mm
- net /Quench trigger/ILOCK_11: track 0.00 -> 18.3 mm
- net /VT1: track 0.00 -> 17.7 mm
- net /Quench trigger/ILOCK_22: track 0.00 -> 16.6 mm
- net /Quench trigger/SW_TRIG+: track 0.00 -> 14.0 mm
- net Net-(TP701-Pad1): track 28.4 -> 16.4 mm
- net /Detection validation/TRIG-CH-B: track 44.2 -> 55.4 mm
- net Net-(U703-Pad6): track 0.00 -> 11.0 mm
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