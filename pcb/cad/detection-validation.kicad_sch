File: pcb/cad/detection-validation.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Validation schematic created
Parts:
- added C301, C302, C303, C304, C305, C306, C307: 0.1u, symbol Device:C
- added C401, C402, C403, C404: 2.2u, symbol Device:C
- added C405, C406, C407, C408: 470p, symbol Device:C
- added R401, R402, R403, R404: 1k, symbol Device:R_US
- added R405, R406, R407, R408: 20k, symbol Device:R_US
- added R409, R410, R411, R412: 2k, symbol Device:R_US
- added RV401, RV402, RV403, RV404: 50k, Potentiometer_SMD:Potentiometer_Bourns_3224X_Vertical, symbol Device:R_Potentiometer_Trim_US
- added SW401: SW_DIP_x05, Button_Switch_SMD:SW_DIP_SPSTx05_Slide_6.7x14.26mm_W8.61mm_P2.54mm_LowProfile, symbol Switch:SW_DIP_x05
- added U401, U402, U403, U404: 74HC123, Package_SO:SOIC-16_3.9x9.9mm_P1.27mm, symbol qds-cv-lib-sym:74HC123
- added U405, U406: 74HC32D, Package_SO:SO-14_3.9x8.65mm_P1.27mm, symbol qds-cv-lib-sym:74HC32D
- added U408: 74HCS08, Package_SO:SO-14_3.9x8.65mm_P1.27mm, symbol qds-cv-lib-sym:74HCS08
Connections:
- new net: R409.1, SW401.10
- new net: C403.2, RV403.1, U403.15 (RCx)
- new net: R401.1, RV401.2, RV401.3
- new net: U401.13 (Q), U405.1, U405.4
- new net: U401.4 (~{Q}), U405.2
- new net: U405.3, U408.1
- new net: R408.1, U408.11
- new net: U404.13 (Q), U406.12, U406.9
- new net: C404.2, RV404.1, U404.15 (RCx)
- new net: U404.4 (~{Q}), U406.10
- new net: R404.1, RV404.2, RV404.3
- new net: R410.1, SW401.9
- new net: U405.6, U408.2
- new net: R406.1, U408.6
- new net: R405.1, U408.3
- new net: C401.2, RV401.1, U401.15 (RCx)
- new net: U402.13 (Q), U405.12, U405.9
- new net: C402.2, RV402.1, U402.15 (RCx)
- new net: U402.4 (~{Q}), U405.10
- new net: U405.8, U408.4
- new net: U406.11, U408.13
- new net: R412.1, SW401.7
- new net: R411.1, SW401.8
- new net: R403.1, RV403.2, RV403.3
- new net: R402.1, RV402.2, RV402.3
- new net: U403.13 (Q), U406.1, U406.4
- new net: U403.4 (~{Q}), U406.2
- new net: U406.8, U408.12
- new net: U406.6, U408.10
- new net: R407.1, U408.8
- new net: U406.3, U408.9
- new net: U405.11, U408.5
- new net +5V: C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, R401.2, R402.2, R403.2, R404.2, R409.2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
- new net Earth: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C401.1, C402.1, C403.1, C404.1, C405.2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
- new net TRIG-CH-A: C405.1, R405.2, SW401.1
- new net TRIG-CH-B: C406.1, R406.2, SW401.2
- new net TRIG-CH-C: C407.1, R407.2, SW401.3
- new net TRIG-CH-D: C408.1, R408.2, SW401.4
- new net VAL-A: U401.1 (A), U405.5
- new net VAL-B: U402.1 (A), U403.1 (A), U405.13, U406.5
- new net VAL-D: U404.1 (A), U406.13

Commit message: specify components used in front-end, validation and power circuits, except resistors
Parts:
- C301, C302, C303, C304, C305, C306, C307: value 0.1u -> 100n; footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; CNPEM Code (none) -> AP107349; Manufacturer (none) -> TDK; Part Number (none) -> C1608X7R1H104K080AA; Vendor Link (none) -> https://br.mouser.com/ProductDetail/TDK/C1608X7R1H104K080AA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
- C401, C402, C403, C404: footprint (none) -> Capacitor_SMD:C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; CNPEM Code (none) -> AP105054; Manufacturer (none) -> Murata; Part Number (none) -> GRM188R71A225KE15
- C405, C406, C407, C408: footprint (none) -> Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Manufacturer (none) -> Samsung; Part Number (none) -> CL21B471KBANNNC
- U405, U406: Manufacturer (none) -> NXP

Commit message: Created hierarchy connections, updates on analog-front-end and included 5V reference circuit
Connections:
- net VAL-B: no longer U403.1 (A), U406.5
- new net VAL-C: U403.1 (A), U406.5
Other:
- note added: "Detection validation"
- note removed: "Detection & Validation"
- moved on the sheet: C405, C406, C407, C408, R405, R406, R407, R408
