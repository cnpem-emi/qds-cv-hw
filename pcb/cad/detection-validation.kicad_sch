File: pcb/cad/detection-validation.kicad_sch (KiCad schematic)
At the start: 39 parts, among them SW401 SW_DIP_x05, U401 74HC123, U402 74HC123, U403 74HC123, U404 74HC123, U405 74HC32D, U406 74HC32D, U408 74HCS08

Commit message: Update power supplies, symbols and footprint libs
Parts:
- removed unit 1 of U402
- removed unit 1 of U403
- added unit 2 of U602
- added unit 1 of U606
- renumbered C401 to C601, C405 to C602, C402 to C603, C406 to C604, C403 to C605, C407 to C606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
Connections:
- net +5V: now also U606.10 (B), U606.11 (Clr), U602.10 (B), U602.11 (Clr), U606.2 (B), U606.3 (Clr); no longer U606.2 (B), U606.3 (Clr)
- net Earth: now also U606.6 (Cx), U602.6 (Cx), U606.14 (Cx); no longer U606.14 (Cx)
- net VAL-B: now also U602.9 (A)
- net VAL-C: now also U606.1 (A)
- net VAL-D: now also U606.9 (A); no longer U606.1 (A)
- net at C605.2, RV603.1: now also U606.15 (RCx)
- net at U605.12, U605.9: now also U606.5 (Q); no longer U606.13 (Q)
- net at C614.2, RV604.1: now also U606.7 (RCx); no longer U606.15 (RCx)
- net at U605.10: now also U606.12 (~{Q}); no longer U606.4 (~{Q})
- net at U601.12, U601.9: now also U602.5 (Q)
- net at C603.2, RV602.1: now also U602.7 (RCx)
- net at U601.10: now also U602.12 (~{Q})
- net at U605.1, U605.4: now also U606.13 (Q)
- net at U605.2: now also U606.4 (~{Q})
Other:
- moved on the sheet: C603, C604, C605, C606, C614, C615, R607, R608, R609, R610, R611, R612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

Commit message: Grouped 74HC123 into two IC's and updated BNC connector 3D model
Parts:
- renumbered U605 to U604, U606 to U605, U607 to U606, U604 to U607
Changed lines of the file:
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@@
   (symbol (lib_id "qds-cv-lib-sym:74HC32D") (at 214.122 128.016 180) (unit 5)
     (in_bom yes) (on_board yes)
-    (property "Reference" "U605" (id 0) (at 217.297 128.016 0)
+    (property "Reference" "U604" (id 0) (at 217.297 128.016 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "qds-cv-lib-sym:74HC123") (at 247.777 128.016 180) (unit 3)
     (in_bom yes) (on_board yes)
-    (property "Reference" "U607" (id 0) (at 250.317 128.016 0)
+    (property "Reference" "U606" (id 0) (at 250.317 128.016 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_name "74HC123_7") (lib_id "qds-cv-lib-sym:74HC123") (at 71.12 175.26 0) (unit 2)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U606" (id 0) (at 71.12 162.56 0))
+    (property "Reference" "U605" (id 0) (at 71.12 162.56 0))
     (property "Value" "74HC123" (id 1) (at 71.12 165.1 0))
     (property "Footprint" "Package_SO:SOIC-16_3.9x9.9mm_P1.27mm" (id 2) (at 71.12 175.26 0)
@@
   (symbol (lib_name "74HC32D_9") (lib_id "qds-cv-lib-sym:74HC32D") (at 102.87 182.88 0) (unit 4)
     (in_bom yes) (on_board yes)
-    (property "Reference" "U605" (id 0) (at 109.22 185.42 0))
+    (property "Reference" "U604" (id 0) (at 109.22 185.42 0))
     (property "Value" "74HC32D" (id 1) (at 109.22 187.96 0))
     (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 102.87 182.88 0)
@@
   (symbol (lib_id "qds-cv-lib-sym:74HC123") (at 236.982 128.016 180) (unit 3)
     (in_bom yes) (on_board yes)
-    (property "Reference" "U606" (id 0) (at 240.157 128.016 0)
+    (property "Reference" "U605" (id 0) (at 240.157 128.016 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "qds-cv-lib-sym:74HC123") (at 71.12 132.08 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "U606" (id 0) (at 71.12 119.38 0))
+    (property "Reference" "U605" (id 0) (at 71.12 119.38 0))
     (property "Value" "74HC123" (id 1) (at 71.12 121.92 0))
     (property "Footprint" "Package_SO:SOIC-16_3.9x9.9mm_P1.27mm" (id 2) (at 71.12 132.08 0)
@@
   (symbol (lib_id "qds-cv-lib-sym:74HC32D") (at 102.87 172.72 0) (unit 3)
     (in_bom yes) (on_board yes)
-    (property "Reference" "U605" (id 0) (at 109.22 166.37 0))
+    (property "Reference" "U604" (id 0) (at 109.22 166.37 0))
     (property "Value" "74HC32D" (id 1) (at 109.22 168.91 0))
     (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 102.87 172.72 0)
@@
   (symbol (lib_name "74HC32D_7") (lib_id "qds-cv-lib-sym:74HC32D") (at 102.87 139.7 0) (unit 2)
     (in_bom yes) (on_board yes)
-    (property "Reference" "U605" (id 0) (at 109.22 142.24 0))
+    (property "Reference" "U604" (id 0) (at 109.22 142.24 0))
     (property "Value" "74HC32D" (id 1) (at 109.22 144.78 0))
     (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 102.87 139.7 0)
@@
   (symbol (lib_id "qds-cv-lib-sym:74HC123") (at 257.937 128.016 180) (unit 3)
     (in_bom yes) (on_board yes)
-    (property "Reference" "U604" (id 0) (at 261.112 128.016 0)
+    (property "Reference" "U607" (id 0) (at 261.112 128.016 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_name "74HC32D_8") (lib_id "qds-cv-lib-sym:74HC32D") (at 102.87 129.54 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "U605" (id 0) (at 109.22 123.19 0))
+    (property "Reference" "U604" (id 0) (at 109.22 123.19 0))
     (property "Value" "74HC32D" (id 1) (at 109.22 125.73 0))
     (property "Footprint" "Package_SO:SO-14_3.9x8.65mm_P1.27mm" (id 2) (at 102.87 129.54 0)
